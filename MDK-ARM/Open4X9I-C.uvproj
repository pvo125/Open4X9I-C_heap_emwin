# Keil uVision project Open4X9I-C.uvproj, settings and files
target Open4X9I-C (ARM-ADS)
  device: STM32F429IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Open4X9I-C +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;..\user;..\user\inc;..\user\PS2_mouse;..\user\GUI;..\user\bxCAN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\user\Open4X9I.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_hcd.c stm32f4xx_hal_dsi.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rtc.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STemWin
    ../user/GUI/: GUI_X.c GUIConf.c LCDConf_stm324x9i_eval_MB1046.c STemWin528_CM4_Keil.lib
  group Picture
    ../user/icons/: alarm.c date.c paint.c photo.c settings.c usb.c alarm_b_d.c alarm_a.c alarm_a_d.c alarm_b.c chip.c rtc_back.c netcan.c update.c
    ../user/backgroung/: xp.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ../user/xpt2046/: tsc2046.c
    ../user/PS2_mouse/: PS2_Mouse.c
    ../user/bxCAN/: CAN.c
  group GUI_DIALOG
    ../user/GUI_DIALOG/: TIME_DATEDLG.c ALARMDLG.c CAN_NETDLG.c MAINWINDOW.c SETTINGSDLG.c
